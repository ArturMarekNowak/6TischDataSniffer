options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: DataSniffer6TSCHDataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 863.042e6
  states: {}
- name: length
  id: variable
  parameters:
    value: '9'
  states: {}
- name: mask
  id: variable
  parameters:
    value: '0x110'
  states: {}
- name: points
  id: variable
  parameters:
    value: '7000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: skip_points
  id: variable
  parameters:
    value: '2202000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate // 200000
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-37'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\notscrambled
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\scrambled.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\repacked.dat
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\6TSCH_ID65535.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: points
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: skip_points
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: sps*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_bb_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '1001000001001110'
    threshold: '0'
  states: {}
- name: digital_descrambler_bb_0_0_0
  id: digital_descrambler_bb
  parameters:
    len: length
    mask: mask
    seed: seed
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_skiphead_0, '0']
- [blocks_head_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_correlate_access_code_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_correlate_access_code_bb_0, '0', blocks_file_sink_0, '0']
- [digital_correlate_access_code_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_correlate_access_code_bb_0, '0', digital_descrambler_bb_0_0_0, '0']
- [digital_descrambler_bb_0_0_0, '0', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
