options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: DataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 863.042e6
  states: {}
- name: divider
  id: variable
  parameters:
    value: '10'
  states: {}
- name: length
  id: variable
  parameters:
    value: '9'
  states: {}
- name: mask
  id: variable
  parameters:
    value: '0x110'
  states: {}
- name: points
  id: variable
  parameters:
    value: '21000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate // 200000
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-37'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\Workspace\6tschDataSniffer\Files\DemodulatedPackets\testtest.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\Workspace\6tschDataSniffer\Files\CapturedPackets\testtest.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '20000000'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '40.2'
    omega_relative_limit: '0.005'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0_0, '0']

metadata:
  file_format: 1
