options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: DataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filterFIR
  id: variable
  parameters:
    value: ' firdes.low_pass(1,samp_rate,150000,70000)'
  states: {}
- name: numpoints
  id: variable
  parameters:
    value: '10240'
  states: {}
- name: omega
  id: variable
  parameters:
    value: 'samp_rate // 50000 '
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_divide
  id: variable
  parameters:
    value: 'samp_rate '
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '-37'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: epy_block_0_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import datetime
      import sqlite3
      import uuid
      import _thread 
      import numpy
      import time

      class blk(gr.sync_block): 

          def __init__(self, channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              
              self.channel = channel
              self.conn = sqlite3.connect("/mnt/c/Users/artur/OneDrive/Desktop/Workspace/6tschDataSniffer/Database/Database.db", check_same_thread=False)
              self.conn.execute("PRAGMA synchronous=OFF")

              self.buffer = []
              self.bufferTimestamp = str(datetime.datetime.now())
              
          def __del__(self):
              self.conn.close()

          def work(self, input_items, output_items):
              
              for i in range(len(input_items[0])):            
                  
                  if input_items[0][i] == 2 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if input_items[0][i] == 3 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if len(self.buffer) > 0 and len(self.buffer) < 88: 
                      
                      self.buffer.append(input_items[0][i])
                  
                  if len(self.buffer) == 88:  
                      
                      length = np.array(self.buffer[:8])
                      length = np.packbits(length, bitorder='big')
                      length.dtype = np.uint8
                                          
                      currentPacketNumber = np.array(self.buffer[8:24])
                      currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')
                      currentPacketNumber.dtype = np.uint16
                                            
                      testId = np.array(self.buffer[24:56])
                      testId = np.packbits(testId, bitorder='big')
                      testId.dtype = np.uint32
                                             
                      totalPacketCount = np.array(self.buffer[56:72])
                      totalPacketCount = np.packbits(totalPacketCount, bitorder='big')
                      totalPacketCount.dtype = np.uint16
                                              
                      payloadDataLength = np.array(self.buffer[72:88])
                      payloadDataLength = np.packbits(payloadDataLength, bitorder='big')
                      payloadDataLength.dtype = np.uint16
                      
                      self.conn.execute(f"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length[0]}', '{currentPacketNumber[0]}','{testId[0]}', '{totalPacketCount[0]}', '{payloadDataLength[0]}' )");
                      self.buffer = []
              
              self.conn.commit()
              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    channel: '''868.3MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import datetime
      import sqlite3
      import uuid
      import _thread 
      import numpy
      import time

      class blk(gr.sync_block): 

          def __init__(self, channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              
              self.channel = channel
              self.conn = sqlite3.connect("/mnt/c/Users/artur/OneDrive/Desktop/Workspace/6tschDataSniffer/Database/Database.db", check_same_thread=False)
              self.conn.execute("PRAGMA synchronous=OFF")

              self.buffer = []
              self.bufferTimestamp = str(datetime.datetime.now())
              
          def __del__(self):
              self.conn.close()

          def work(self, input_items, output_items):
              
              for i in range(len(input_items[0])):            
                  
                  if input_items[0][i] == 2 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if input_items[0][i] == 3 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if len(self.buffer) > 0 and len(self.buffer) < 88: 
                      
                      self.buffer.append(input_items[0][i])
                  
                  if len(self.buffer) == 88:  
                      
                      length = np.array(self.buffer[:8])
                      length = np.packbits(length, bitorder='big')
                      length.dtype = np.uint8
                                          
                      currentPacketNumber = np.array(self.buffer[8:24])
                      currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')
                      currentPacketNumber.dtype = np.uint16
                                            
                      testId = np.array(self.buffer[24:56])
                      testId = np.packbits(testId, bitorder='big')
                      testId.dtype = np.uint32
                                             
                      totalPacketCount = np.array(self.buffer[56:72])
                      totalPacketCount = np.packbits(totalPacketCount, bitorder='big')
                      totalPacketCount.dtype = np.uint16
                                              
                      payloadDataLength = np.array(self.buffer[72:88])
                      payloadDataLength = np.packbits(payloadDataLength, bitorder='big')
                      payloadDataLength.dtype = np.uint16
                      
                      self.conn.execute(f"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length[0]}', '{currentPacketNumber[0]}','{testId[0]}', '{totalPacketCount[0]}', '{payloadDataLength[0]}' )");
                      self.buffer = []
              
              self.conn.commit()
              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    channel: '''868.7MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import datetime
      import sqlite3
      import uuid
      import _thread 
      import numpy
      import time

      class blk(gr.sync_block): 

          def __init__(self, channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              
              self.channel = channel
              self.conn = sqlite3.connect("/mnt/c/Users/artur/OneDrive/Desktop/Workspace/6tschDataSniffer/Database/Database.db", check_same_thread=False)
              self.conn.execute("PRAGMA synchronous=OFF")

              self.buffer = []
              self.bufferTimestamp = str(datetime.datetime.now())
              
          def __del__(self):
              self.conn.close()

          def work(self, input_items, output_items):
              
              for i in range(len(input_items[0])):            
                  
                  if input_items[0][i] == 2 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if input_items[0][i] == 3 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if len(self.buffer) > 0 and len(self.buffer) < 88: 
                      
                      self.buffer.append(input_items[0][i])
                  
                  if len(self.buffer) == 88:  
                      
                      length = np.array(self.buffer[:8])
                      length = np.packbits(length, bitorder='big')
                      length.dtype = np.uint8
                                          
                      currentPacketNumber = np.array(self.buffer[8:24])
                      currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')
                      currentPacketNumber.dtype = np.uint16
                                            
                      testId = np.array(self.buffer[24:56])
                      testId = np.packbits(testId, bitorder='big')
                      testId.dtype = np.uint32
                                             
                      totalPacketCount = np.array(self.buffer[56:72])
                      totalPacketCount = np.packbits(totalPacketCount, bitorder='big')
                      totalPacketCount.dtype = np.uint16
                                              
                      payloadDataLength = np.array(self.buffer[72:88])
                      payloadDataLength = np.packbits(payloadDataLength, bitorder='big')
                      payloadDataLength.dtype = np.uint16
                      
                      self.conn.execute(f"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length[0]}', '{currentPacketNumber[0]}','{testId[0]}', '{totalPacketCount[0]}', '{payloadDataLength[0]}' )");
                      self.buffer = []
              
              self.conn.commit()
              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    channel: '''869.9MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import datetime
      import sqlite3
      import uuid
      import _thread 
      import numpy
      import time

      class blk(gr.sync_block): 

          def __init__(self, channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              
              self.channel = channel
              self.conn = sqlite3.connect("/mnt/c/Users/artur/OneDrive/Desktop/Workspace/6tschDataSniffer/Database/Database.db", check_same_thread=False)
              self.conn.execute("PRAGMA synchronous=OFF")

              self.buffer = []
              self.bufferTimestamp = str(datetime.datetime.now())
              
          def __del__(self):
              self.conn.close()

          def work(self, input_items, output_items):
              
              for i in range(len(input_items[0])):            
                  
                  if input_items[0][i] == 2 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if input_items[0][i] == 3 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if len(self.buffer) > 0 and len(self.buffer) < 88: 
                      
                      self.buffer.append(input_items[0][i])
                  
                  if len(self.buffer) == 88:  
                      
                      length = np.array(self.buffer[:8])
                      length = np.packbits(length, bitorder='big')
                      length.dtype = np.uint8
                                          
                      currentPacketNumber = np.array(self.buffer[8:24])
                      currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')
                      currentPacketNumber.dtype = np.uint16
                                            
                      testId = np.array(self.buffer[24:56])
                      testId = np.packbits(testId, bitorder='big')
                      testId.dtype = np.uint32
                                             
                      totalPacketCount = np.array(self.buffer[56:72])
                      totalPacketCount = np.packbits(totalPacketCount, bitorder='big')
                      totalPacketCount.dtype = np.uint16
                                              
                      payloadDataLength = np.array(self.buffer[72:88])
                      payloadDataLength = np.packbits(payloadDataLength, bitorder='big')
                      payloadDataLength.dtype = np.uint16
                      
                      self.conn.execute(f"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length[0]}', '{currentPacketNumber[0]}','{testId[0]}', '{totalPacketCount[0]}', '{payloadDataLength[0]}' )");
                      self.buffer = []
              
              self.conn.commit()
              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    channel: '''869.5MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import datetime
      import sqlite3
      import uuid
      import _thread 
      import numpy
      import time

      class blk(gr.sync_block): 

          def __init__(self, channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              
              self.channel = channel
              self.conn = sqlite3.connect("/mnt/c/Users/artur/OneDrive/Desktop/Workspace/6tschDataSniffer/Database/Database.db", check_same_thread=False)
              self.conn.execute("PRAGMA synchronous=OFF")

              self.buffer = []
              self.bufferTimestamp = str(datetime.datetime.now())
              
          def __del__(self):
              self.conn.close()

          def work(self, input_items, output_items):
              
              for i in range(len(input_items[0])):            
                  
                  if input_items[0][i] == 2 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if input_items[0][i] == 3 and len(self.buffer) == 0:  
                      
                      self.bufferTimestamp = str(datetime.datetime.now())
                      self.buffer.append(0)
                      continue
                      
                  if len(self.buffer) > 0 and len(self.buffer) < 88: 
                      
                      self.buffer.append(input_items[0][i])
                  
                  if len(self.buffer) == 88:  
                      
                      length = np.array(self.buffer[:8])
                      length = np.packbits(length, bitorder='big')
                      length.dtype = np.uint8
                                          
                      currentPacketNumber = np.array(self.buffer[8:24])
                      currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')
                      currentPacketNumber.dtype = np.uint16
                                            
                      testId = np.array(self.buffer[24:56])
                      testId = np.packbits(testId, bitorder='big')
                      testId.dtype = np.uint32
                                             
                      totalPacketCount = np.array(self.buffer[56:72])
                      totalPacketCount = np.packbits(totalPacketCount, bitorder='big')
                      totalPacketCount.dtype = np.uint16
                                              
                      payloadDataLength = np.array(self.buffer[72:88])
                      payloadDataLength = np.packbits(payloadDataLength, bitorder='big')
                      payloadDataLength.dtype = np.uint16
                      
                      self.conn.execute(f"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length[0]}', '{currentPacketNumber[0]}','{testId[0]}', '{totalPacketCount[0]}', '{payloadDataLength[0]}' )");
                      self.buffer = []
              
              self.conn.commit()
              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    channel: '''869.1MHz'''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-800000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '800000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-400000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '400000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 52"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 68"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 56"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 64"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 62"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: 869.1e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_moving_average_xx_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_moving_average_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2, '0']
- [blocks_uchar_to_float_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0_0_0_0_0_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', epy_block_0_0_0_0_0_0_0_1, '0']
- [digital_binary_slicer_fb_0_0_0, '0', epy_block_0_0_0_0_0_0_0_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', epy_block_0_0_0_0_0_0_0_2, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0, '0', epy_block_0_0_0_0_0_0_0_3, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_1, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_2, '0', blocks_uchar_to_float_0_0_0_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_3, '0', blocks_uchar_to_float_0_0_0_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_simple_squelch_cc_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
