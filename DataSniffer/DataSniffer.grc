options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: DataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filterFIR
  id: variable
  parameters:
    value: ' firdes.low_pass(1,samp_rate,150000,70000)'
  states: {}
- name: numpoints
  id: variable
  parameters:
    value: '10240'
  states: {}
- name: omega
  id: variable
  parameters:
    value: 'samp_rate // 50000 '
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_divide
  id: variable
  parameters:
    value: 'samp_rate '
  states: {}
- name: tagName
  id: variable
  parameters:
    value: '"SFD"'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '-37'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1001000001001110'
    tagname: tagName
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1001000001001110'
    tagname: tagName
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1001000001001110'
    tagname: tagName
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1001000001001110'
    tagname: tagName
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0_2
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1001000001001110'
    tagname: tagName
    threshold: '0'
    type: byte
  states: {}
- name: epy_block_0_0_0_0_0_0_0_4_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport datetime\nimport sqlite3\nimport uuid\nimport _thread \nimport numpy\nimport time\nimport pmt\n\nclass blk(gr.sync_block): \n\n    def __init__(self, channel='channel'):  \n\n        gr.sync_block.__init__(\n            self,\n            name='Packet parser',   \n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        \n        self.channel = channel\n        self.conn = sqlite3.connect(\"/home/artur/Desktop/Workspace/6tschDataSniffer/Database/Database.db\", check_same_thread=False)\n        self.conn.execute(\"PRAGMA synchronous=OFF\")\n\n        self.buffer = []\n        self.bufferTimestamp = str(datetime.datetime.now())\n        \n    def __del__(self):\n        self.conn.close()\n\n   \n    def work(self, input_items, output_items):\n       \n        if len(self.buffer) != 0:\n\n            if len(self.buffer) + len(input_items[0]) < 88:\n                #print(\"DEBUG 3\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0])\n                #print(\"DEBUG 4\" + str(len(self.buffer)))\n                return len(output_items[0])\n\n            if len(self.buffer) + len(input_items[0]) >= 88:\n                #print(\"DEBUG 5\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0][:(88 - len(self.buffer))])\n                #print(\"DEBUG 6\" + str(len(self.buffer))) \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(self.buffer)      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n                self.buffer = []\n                #print(\"DEBUG 7\" + str(len(self.buffer))) \n                \n        tags = self.get_tags_in_window(0, 0, len(input_items[0]))\n        for tag in tags:\n           \n            timestamp = str(datetime.datetime.now())\n            offset = tag.offset - self.nitems_read(0)                \n            \n            if len(input_items[0]) - offset >= 88: \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(input_items[0][offset:offset+88])      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{timestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n            \n            else:\n                #print(\"DEBUG 1\" + str(len(self.buffer)))\n                self.bufferTimestamp = str(datetime.datetime.now())\n                self.buffer.extend(input_items[0][offset:len(input_items[0])])\n                #print(\"DEBUG 2\" + str(len(self.buffer)))\n                \n        self.conn.commit()\n        output_items[0][:] = input_items[0][:]\n        return len(output_items[0]) \n\n    def formData(self, input_buffer):\n        length = np.array(input_buffer[:8])\n        length = np.packbits(length, bitorder='big')\n        length.dtype = np.uint8\n                                    \n        currentPacketNumber = np.array(input_buffer[8:24])\n        currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')\n        currentPacketNumber.dtype = np.uint16\n                                      \n        testId = np.array(input_buffer[24:56])\n        testId = np.packbits(testId, bitorder='big')\n        testId.dtype = np.uint32\n                                    \n        totalPacketCount = np.array(input_buffer[56:72])\n        totalPacketCount = np.packbits(totalPacketCount, bitorder='big')\n        totalPacketCount.dtype = np.uint16\n                                        \n        payloadDataLength = np.array(input_buffer[72:88])\n        payloadDataLength = np.packbits(payloadDataLength, bitorder='big')\n        payloadDataLength.dtype = np.uint16\n        return str(length), str(currentPacketNumber), str(testId), str(totalPacketCount), str(payloadDataLength)      \n\n\n"
    channel: '''868.3MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_4_1_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport datetime\nimport sqlite3\nimport uuid\nimport _thread \nimport numpy\nimport time\nimport pmt\n\nclass blk(gr.sync_block): \n\n    def __init__(self, channel='channel'):  \n\n        gr.sync_block.__init__(\n            self,\n            name='Packet parser',   \n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        \n        self.channel = channel\n        self.conn = sqlite3.connect(\"/home/artur/Desktop/Workspace/6tschDataSniffer/Database/Database.db\", check_same_thread=False)\n        self.conn.execute(\"PRAGMA synchronous=OFF\")\n\n        self.buffer = []\n        self.bufferTimestamp = str(datetime.datetime.now())\n        \n    def __del__(self):\n        self.conn.close()\n\n   \n    def work(self, input_items, output_items):\n       \n        if len(self.buffer) != 0:\n\n            if len(self.buffer) + len(input_items[0]) < 88:\n                #print(\"DEBUG 3\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0])\n                #print(\"DEBUG 4\" + str(len(self.buffer)))\n                return len(output_items[0])\n\n            if len(self.buffer) + len(input_items[0]) >= 88:\n                #print(\"DEBUG 5\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0][:(88 - len(self.buffer))])\n                #print(\"DEBUG 6\" + str(len(self.buffer))) \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(self.buffer)      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n                self.buffer = []\n                #print(\"DEBUG 7\" + str(len(self.buffer))) \n                \n        tags = self.get_tags_in_window(0, 0, len(input_items[0]))\n        for tag in tags:\n           \n            timestamp = str(datetime.datetime.now())\n            offset = tag.offset - self.nitems_read(0)                \n            \n            if len(input_items[0]) - offset >= 88: \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(input_items[0][offset:offset+88])      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{timestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n            \n            else:\n                #print(\"DEBUG 1\" + str(len(self.buffer)))\n                self.bufferTimestamp = str(datetime.datetime.now())\n                self.buffer.extend(input_items[0][offset:len(input_items[0])])\n                #print(\"DEBUG 2\" + str(len(self.buffer)))\n                \n        self.conn.commit()\n        output_items[0][:] = input_items[0][:]\n        return len(output_items[0]) \n\n    def formData(self, input_buffer):\n        length = np.array(input_buffer[:8])\n        length = np.packbits(length, bitorder='big')\n        length.dtype = np.uint8\n                                    \n        currentPacketNumber = np.array(input_buffer[8:24])\n        currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')\n        currentPacketNumber.dtype = np.uint16\n                                      \n        testId = np.array(input_buffer[24:56])\n        testId = np.packbits(testId, bitorder='big')\n        testId.dtype = np.uint32\n                                    \n        totalPacketCount = np.array(input_buffer[56:72])\n        totalPacketCount = np.packbits(totalPacketCount, bitorder='big')\n        totalPacketCount.dtype = np.uint16\n                                        \n        payloadDataLength = np.array(input_buffer[72:88])\n        payloadDataLength = np.packbits(payloadDataLength, bitorder='big')\n        payloadDataLength.dtype = np.uint16\n        return str(length), str(currentPacketNumber), str(testId), str(totalPacketCount), str(payloadDataLength)      \n\n\n"
    channel: '''869.9MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_4_1_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport datetime\nimport sqlite3\nimport uuid\nimport _thread \nimport numpy\nimport time\nimport pmt\n\nclass blk(gr.sync_block): \n\n    def __init__(self, channel='channel'):  \n\n        gr.sync_block.__init__(\n            self,\n            name='Packet parser',   \n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        \n        self.channel = channel\n        self.conn = sqlite3.connect(\"/home/artur/Desktop/Workspace/6tschDataSniffer/Database/Database.db\", check_same_thread=False)\n        self.conn.execute(\"PRAGMA synchronous=OFF\")\n\n        self.buffer = []\n        self.bufferTimestamp = str(datetime.datetime.now())\n        \n    def __del__(self):\n        self.conn.close()\n\n   \n    def work(self, input_items, output_items):\n       \n        if len(self.buffer) != 0:\n\n            if len(self.buffer) + len(input_items[0]) < 88:\n                #print(\"DEBUG 3\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0])\n                #print(\"DEBUG 4\" + str(len(self.buffer)))\n                return len(output_items[0])\n\n            if len(self.buffer) + len(input_items[0]) >= 88:\n                #print(\"DEBUG 5\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0][:(88 - len(self.buffer))])\n                #print(\"DEBUG 6\" + str(len(self.buffer))) \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(self.buffer)      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n                self.buffer = []\n                #print(\"DEBUG 7\" + str(len(self.buffer))) \n                \n        tags = self.get_tags_in_window(0, 0, len(input_items[0]))\n        for tag in tags:\n           \n            timestamp = str(datetime.datetime.now())\n            offset = tag.offset - self.nitems_read(0)                \n            \n            if len(input_items[0]) - offset >= 88: \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(input_items[0][offset:offset+88])      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{timestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n            \n            else:\n                #print(\"DEBUG 1\" + str(len(self.buffer)))\n                self.bufferTimestamp = str(datetime.datetime.now())\n                self.buffer.extend(input_items[0][offset:len(input_items[0])])\n                #print(\"DEBUG 2\" + str(len(self.buffer)))\n                \n        self.conn.commit()\n        output_items[0][:] = input_items[0][:]\n        return len(output_items[0]) \n\n    def formData(self, input_buffer):\n        length = np.array(input_buffer[:8])\n        length = np.packbits(length, bitorder='big')\n        length.dtype = np.uint8\n                                    \n        currentPacketNumber = np.array(input_buffer[8:24])\n        currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')\n        currentPacketNumber.dtype = np.uint16\n                                      \n        testId = np.array(input_buffer[24:56])\n        testId = np.packbits(testId, bitorder='big')\n        testId.dtype = np.uint32\n                                    \n        totalPacketCount = np.array(input_buffer[56:72])\n        totalPacketCount = np.packbits(totalPacketCount, bitorder='big')\n        totalPacketCount.dtype = np.uint16\n                                        \n        payloadDataLength = np.array(input_buffer[72:88])\n        payloadDataLength = np.packbits(payloadDataLength, bitorder='big')\n        payloadDataLength.dtype = np.uint16\n        return str(length), str(currentPacketNumber), str(testId), str(totalPacketCount), str(payloadDataLength)      \n\n\n"
    channel: '''868.7MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_4_1_0_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport datetime\nimport sqlite3\nimport uuid\nimport _thread \nimport numpy\nimport time\nimport pmt\n\nclass blk(gr.sync_block): \n\n    def __init__(self, channel='channel'):  \n\n        gr.sync_block.__init__(\n            self,\n            name='Packet parser',   \n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        \n        self.channel = channel\n        self.conn = sqlite3.connect(\"/home/artur/Desktop/Workspace/6tschDataSniffer/Database/Database.db\", check_same_thread=False)\n        self.conn.execute(\"PRAGMA synchronous=OFF\")\n\n        self.buffer = []\n        self.bufferTimestamp = str(datetime.datetime.now())\n        \n    def __del__(self):\n        self.conn.close()\n\n   \n    def work(self, input_items, output_items):\n       \n        if len(self.buffer) != 0:\n\n            if len(self.buffer) + len(input_items[0]) < 88:\n                #print(\"DEBUG 3\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0])\n                #print(\"DEBUG 4\" + str(len(self.buffer)))\n                return len(output_items[0])\n\n            if len(self.buffer) + len(input_items[0]) >= 88:\n                #print(\"DEBUG 5\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0][:(88 - len(self.buffer))])\n                #print(\"DEBUG 6\" + str(len(self.buffer))) \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(self.buffer)      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n                self.buffer = []\n                #print(\"DEBUG 7\" + str(len(self.buffer))) \n                \n        tags = self.get_tags_in_window(0, 0, len(input_items[0]))\n        for tag in tags:\n           \n            timestamp = str(datetime.datetime.now())\n            offset = tag.offset - self.nitems_read(0)                \n            \n            if len(input_items[0]) - offset >= 88: \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(input_items[0][offset:offset+88])      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{timestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n            \n            else:\n                #print(\"DEBUG 1\" + str(len(self.buffer)))\n                self.bufferTimestamp = str(datetime.datetime.now())\n                self.buffer.extend(input_items[0][offset:len(input_items[0])])\n                #print(\"DEBUG 2\" + str(len(self.buffer)))\n                \n        self.conn.commit()\n        output_items[0][:] = input_items[0][:]\n        return len(output_items[0]) \n\n    def formData(self, input_buffer):\n        length = np.array(input_buffer[:8])\n        length = np.packbits(length, bitorder='big')\n        length.dtype = np.uint8\n                                    \n        currentPacketNumber = np.array(input_buffer[8:24])\n        currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')\n        currentPacketNumber.dtype = np.uint16\n                                      \n        testId = np.array(input_buffer[24:56])\n        testId = np.packbits(testId, bitorder='big')\n        testId.dtype = np.uint32\n                                    \n        totalPacketCount = np.array(input_buffer[56:72])\n        totalPacketCount = np.packbits(totalPacketCount, bitorder='big')\n        totalPacketCount.dtype = np.uint16\n                                        \n        payloadDataLength = np.array(input_buffer[72:88])\n        payloadDataLength = np.packbits(payloadDataLength, bitorder='big')\n        payloadDataLength.dtype = np.uint16\n        return str(length), str(currentPacketNumber), str(testId), str(totalPacketCount), str(payloadDataLength)      \n\n\n"
    channel: '''869.5MHz'''
  states: {}
- name: epy_block_0_0_0_0_0_0_0_4_1_0_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport datetime\nimport sqlite3\nimport uuid\nimport _thread \nimport numpy\nimport time\nimport pmt\n\nclass blk(gr.sync_block): \n\n    def __init__(self, channel='channel'):  \n\n        gr.sync_block.__init__(\n            self,\n            name='Packet parser',   \n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        \n        self.channel = channel\n        self.conn = sqlite3.connect(\"/home/artur/Desktop/Workspace/6tschDataSniffer/Database/Database.db\", check_same_thread=False)\n        self.conn.execute(\"PRAGMA synchronous=OFF\")\n\n        self.buffer = []\n        self.bufferTimestamp = str(datetime.datetime.now())\n        \n    def __del__(self):\n        self.conn.close()\n\n   \n    def work(self, input_items, output_items):\n       \n        if len(self.buffer) != 0:\n\n            if len(self.buffer) + len(input_items[0]) < 88:\n                #print(\"DEBUG 3\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0])\n                #print(\"DEBUG 4\" + str(len(self.buffer)))\n                return len(output_items[0])\n\n            if len(self.buffer) + len(input_items[0]) >= 88:\n                #print(\"DEBUG 5\" + str(len(self.buffer)))\n                self.buffer.extend(input_items[0][:(88 - len(self.buffer))])\n                #print(\"DEBUG 6\" + str(len(self.buffer))) \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(self.buffer)      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{self.bufferTimestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n                self.buffer = []\n                #print(\"DEBUG 7\" + str(len(self.buffer))) \n                \n        tags = self.get_tags_in_window(0, 0, len(input_items[0]))\n        for tag in tags:\n           \n            timestamp = str(datetime.datetime.now())\n            offset = tag.offset - self.nitems_read(0)                \n            \n            if len(input_items[0]) - offset >= 88: \n                length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.formData(input_items[0][offset:offset+88])      \n                self.conn.execute(f\"INSERT INTO Log (Timestamp,Channel,Length,CurrentPacketNumber,TestId,TotalPacketCount,PayloadDataLength) VALUES ('{timestamp}', '{self.channel}', '{length}', '{currentPacketNumber}','{testId}', '{totalPacketCount}', '{payloadDataLength}' )\");\n            \n            else:\n                #print(\"DEBUG 1\" + str(len(self.buffer)))\n                self.bufferTimestamp = str(datetime.datetime.now())\n                self.buffer.extend(input_items[0][offset:len(input_items[0])])\n                #print(\"DEBUG 2\" + str(len(self.buffer)))\n                \n        self.conn.commit()\n        output_items[0][:] = input_items[0][:]\n        return len(output_items[0]) \n\n    def formData(self, input_buffer):\n        length = np.array(input_buffer[:8])\n        length = np.packbits(length, bitorder='big')\n        length.dtype = np.uint8\n                                    \n        currentPacketNumber = np.array(input_buffer[8:24])\n        currentPacketNumber = np.packbits(currentPacketNumber, bitorder='big')\n        currentPacketNumber.dtype = np.uint16\n                                      \n        testId = np.array(input_buffer[24:56])\n        testId = np.packbits(testId, bitorder='big')\n        testId.dtype = np.uint32\n                                    \n        totalPacketCount = np.array(input_buffer[56:72])\n        totalPacketCount = np.packbits(totalPacketCount, bitorder='big')\n        totalPacketCount.dtype = np.uint16\n                                        \n        payloadDataLength = np.array(input_buffer[72:88])\n        payloadDataLength = np.packbits(payloadDataLength, bitorder='big')\n        payloadDataLength.dtype = np.uint16\n        return str(length), str(currentPacketNumber), str(testId), str(totalPacketCount), str(payloadDataLength)      \n\n\n"
    channel: '''869.1MHz'''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-800000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '800000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-400000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '400000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 52"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 68"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 56"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 64"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 62"'
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: 869.1e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_moving_average_xx_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_moving_average_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2, '0']
- [blocks_uchar_to_float_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_2_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', digital_correlate_access_code_tag_xx_0_0_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', digital_correlate_access_code_tag_xx_0_0_1, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0, '0', digital_correlate_access_code_tag_xx_0_0_2, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_0_0_0_0_0_0_0_4_1, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', epy_block_0_0_0_0_0_0_0_4_1_0, '0']
- [digital_correlate_access_code_tag_xx_0_0_0, '0', epy_block_0_0_0_0_0_0_0_4_1_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0_1, '0', epy_block_0_0_0_0_0_0_0_4_1_0_1, '0']
- [digital_correlate_access_code_tag_xx_0_0_2, '0', epy_block_0_0_0_0_0_0_0_4_1_0_2, '0']
- [epy_block_0_0_0_0_0_0_0_4_1, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_4_1_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_4_1_0_0, '0', blocks_uchar_to_float_0_0_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_4_1_0_1, '0', blocks_uchar_to_float_0_0_0_0_0_0_0, '0']
- [epy_block_0_0_0_0_0_0_0_4_1_0_2, '0', blocks_uchar_to_float_0_0_0_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_simple_squelch_cc_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
