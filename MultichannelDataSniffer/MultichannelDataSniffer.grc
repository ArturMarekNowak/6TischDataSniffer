options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: MultichannelDataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"ch0"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"ch0"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    bb_gain1: '10'
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: 863.1e6
    freq1: 863.2e6
    gain0: '0'
    gain1: '0'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '10'
    if_gain1: '10'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [rtlsdr_source_0, '1', qtgui_waterfall_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
