options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: MultichannelDataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filterFIR
  id: variable
  parameters:
    value: ' firdes.low_pass(1,samp_rate,70000,5000)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_divide
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '-3'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-150000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-50000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '50000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '150000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch0"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch1"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch2"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch3"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 863.25e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_simple_squelch_cc_0_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']

metadata:
  file_format: 1
