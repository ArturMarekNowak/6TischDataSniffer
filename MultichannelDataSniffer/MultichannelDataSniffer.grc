options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: MultichannelDataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filterFIR
  id: variable
  parameters:
    value: ' firdes.low_pass(1,samp_rate,70000,5000)'
  states: {}
- name: omega
  id: variable
  parameters:
    value: '40.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_divide
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '-3'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_simple_squelch_cc_0_0_0_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: omega
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_bb_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '1001000001001110'
    threshold: '0'
  states: {}
- name: digital_correlate_access_code_bb_0_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '1001000001001110'
    threshold: '0'
  states: {}
- name: digital_correlate_access_code_bb_0_0_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '1001000001001110'
    threshold: '0'
  states: {}
- name: digital_correlate_access_code_bb_0_0_0_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '1001000001001110'
    threshold: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import datetime

      class blk(gr.sync_block): 

          def __init__(self, path='C:/Users/artur/OneDrive/Desktop/foo.txt', channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[]
              )
              
              self.path = path
              self.channel = channel
              
          def work(self, input_items, output_items):
              
              file = open(self.path, 'a')
              
              for i in range(len(input_items[0])):
              
                  if input_items[0][i] == 2:
                  
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 0
         
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
                      
                  if input_items[0][i] == 3:
                      
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 1
                      
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
          
              file.close()
              return 0
              
          def decodePacketPayload(self, lengthBits, currentPacketNumberBits, testIdBits, totalPacketCountBits, payloadDataLengthBits):
          
              array = np.array(lengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint8
              
              length = array[0]
              
              array = np.array(currentPacketNumberBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              currentPacketNumber = array[0]
              
              array = np.array(testIdBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint32
              
              testId = array[0]
              
              array = np.array(totalPacketCountBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              totalPacketCount = array[0]
              
              array = np.array(payloadDataLengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              payloadDataLength = array[0]
          
              return length, currentPacketNumber, testId, totalPacketCount, payloadDataLength
              
              
          def inputBitsToString(self, array):
              resultString = ""
              
              for digit in array:
                  resultString += str(digit)

              return resultString
    channel: '''863.1MHz'''
    path: '''C:/Users/artur/OneDrive/Desktop/foo.txt'''
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import datetime

      class blk(gr.sync_block): 

          def __init__(self, path='C:/Users/artur/OneDrive/Desktop/foo.txt', channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[]
              )
              
              self.path = path
              self.channel = channel
              
          def work(self, input_items, output_items):
              
              file = open(self.path, 'a')
              
              for i in range(len(input_items[0])):
              
                  if input_items[0][i] == 2:
                  
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 0
         
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
                      
                  if input_items[0][i] == 3:
                      
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 1
                      
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
          
              file.close()
              return 0
              
          def decodePacketPayload(self, lengthBits, currentPacketNumberBits, testIdBits, totalPacketCountBits, payloadDataLengthBits):
          
              array = np.array(lengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint8
              
              length = array[0]
              
              array = np.array(currentPacketNumberBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              currentPacketNumber = array[0]
              
              array = np.array(testIdBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint32
              
              testId = array[0]
              
              array = np.array(totalPacketCountBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              totalPacketCount = array[0]
              
              array = np.array(payloadDataLengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              payloadDataLength = array[0]
          
              return length, currentPacketNumber, testId, totalPacketCount, payloadDataLength
              
              
          def inputBitsToString(self, array):
              resultString = ""
              
              for digit in array:
                  resultString += str(digit)

              return resultString
    channel: '''863.2MHz'''
    path: '''C:/Users/artur/OneDrive/Desktop/foo.txt'''
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import datetime

      class blk(gr.sync_block): 

          def __init__(self, path='C:/Users/artur/OneDrive/Desktop/foo.txt', channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[]
              )
              
              self.path = path
              self.channel = channel
              
          def work(self, input_items, output_items):
              
              file = open(self.path, 'a')
              
              for i in range(len(input_items[0])):
              
                  if input_items[0][i] == 2:
                  
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 0
         
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
                      
                  if input_items[0][i] == 3:
                      
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 1
                      
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
          
              file.close()
              return 0
              
          def decodePacketPayload(self, lengthBits, currentPacketNumberBits, testIdBits, totalPacketCountBits, payloadDataLengthBits):
          
              array = np.array(lengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint8
              
              length = array[0]
              
              array = np.array(currentPacketNumberBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              currentPacketNumber = array[0]
              
              array = np.array(testIdBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint32
              
              testId = array[0]
              
              array = np.array(totalPacketCountBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              totalPacketCount = array[0]
              
              array = np.array(payloadDataLengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              payloadDataLength = array[0]
          
              return length, currentPacketNumber, testId, totalPacketCount, payloadDataLength
              
              
          def inputBitsToString(self, array):
              resultString = ""
              
              for digit in array:
                  resultString += str(digit)

              return resultString
    channel: '''863.3MHz'''
    path: '''C:/Users/artur/OneDrive/Desktop/foo.txt'''
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import datetime

      class blk(gr.sync_block): 

          def __init__(self, path='C:/Users/artur/OneDrive/Desktop/foo.txt', channel='channel'):  

              gr.sync_block.__init__(
                  self,
                  name='Packet parser',   
                  in_sig=[np.byte],
                  out_sig=[]
              )
              
              self.path = path
              self.channel = channel
              
          def work(self, input_items, output_items):
              
              file = open(self.path, 'a')
              
              for i in range(len(input_items[0])):
              
                  if input_items[0][i] == 2:
                  
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 0
         
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
                      
                  if input_items[0][i] == 3:
                      
                      file.write(str(datetime.datetime.now()))
                      input_items[0][i] = 1
                      
                      length, currentPacketNumber, testId, totalPacketCount, payloadDataLength = self.decodePacketPayload(input_items[0][i:i+8], input_items[0][i+8:i+24], input_items[0][i+24:i+56], input_items[0][i+56:i+72], input_items[0][i+72:i+88])
                      file.write("{: >20} {: >20} {: >20} {: >20} {: >20} {: >20}\n".format(self.channel, length, currentPacketNumber, testId, totalPacketCount, payloadDataLength))
          
              file.close()
              return 0
              
          def decodePacketPayload(self, lengthBits, currentPacketNumberBits, testIdBits, totalPacketCountBits, payloadDataLengthBits):
          
              array = np.array(lengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint8
              
              length = array[0]
              
              array = np.array(currentPacketNumberBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              currentPacketNumber = array[0]
              
              array = np.array(testIdBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint32
              
              testId = array[0]
              
              array = np.array(totalPacketCountBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              totalPacketCount = array[0]
              
              array = np.array(payloadDataLengthBits)
              array = np.packbits(array, bitorder='big')
              array.dtype = np.uint16
              
              payloadDataLength = array[0]
          
              return length, currentPacketNumber, testId, totalPacketCount, payloadDataLength
              
              
          def inputBitsToString(self, array):
              resultString = ""
              
              for digit in array:
                  resultString += str(digit)

              return resultString
    channel: '''863.4MHz'''
    path: '''C:/Users/artur/OneDrive/Desktop/foo.txt'''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-150000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-50000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '50000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '150000'
    decim: '1'
    samp_rate: samp_rate_divide
    taps: filterFIR
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch0"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch1"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch2"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ch3"'
    size: '102400'
    srate: samp_rate_divide
    type: float
    update_time: '10'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 863.25e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_moving_average_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_simple_squelch_cc_0_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [analog_simple_squelch_cc_0_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_moving_average_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_bb_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_correlate_access_code_bb_0_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', digital_correlate_access_code_bb_0_0_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', digital_correlate_access_code_bb_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [digital_correlate_access_code_bb_0, '0', epy_block_0, '0']
- [digital_correlate_access_code_bb_0_0, '0', epy_block_0_0, '0']
- [digital_correlate_access_code_bb_0_0_0, '0', epy_block_0_0_0, '0']
- [digital_correlate_access_code_bb_0_0_0_0, '0', epy_block_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_simple_squelch_cc_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']

metadata:
  file_format: 1
