options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: xDDD
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 863.042e6
  states: {}
- name: length
  id: variable
  parameters:
    value: '9'
  states: {}
- name: mask
  id: variable
  parameters:
    value: '0x110'
  states: {}
- name: number_of_samples
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: number_of_samples_after_decimation
  id: variable
  parameters:
    value: number_of_samples // sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate // 400000
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '2'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-37'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\6TSCH_ID65535.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: number_of_samples
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_descrambler_bb_0_0_0
  id: digital_descrambler_bb
  parameters:
    len: length
    mask: mask
    seed: seed
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: qtgui_time_sink_x_1_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: after descrambling
    size: number_of_samples_after_decimation
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_1_1_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: symbol suync
    size: number_of_samples_after_decimation
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_1_1_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: before descrambling
    size: number_of_samples_after_decimation
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_1_1_0_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: analog
    size: number_of_samples
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_moving_average_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_1_1_0_0_1_0_1, '0']
- [blocks_uchar_to_float_0_0_0_1, '0', qtgui_time_sink_x_1_1_0_0_1, '0']
- [blocks_uchar_to_float_0_0_0_1_0, '0', qtgui_time_sink_x_1_1_0_0_1_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_uchar_to_float_0_0_0_1_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_descrambler_bb_0_0_0, '0']
- [digital_descrambler_bb_0_0_0, '0', blocks_uchar_to_float_0_0_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1_1_0_0_1_0, '0']

metadata:
  file_format: 1
