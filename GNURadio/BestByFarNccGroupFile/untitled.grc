options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: xDDD
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 863.042e6
  states: {}
- name: number_of_samples
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-37'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\6TSCHv3.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: number_of_samples
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '512'
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '9'
    mask: '0x11'
    seed: '0x01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Analog"'
    size: number_of_samples
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"DIgital before descrambling"'
    size: number_of_samples
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"DIgital before descrambling"'
    size: number_of_samples
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_descrambler_bb_0, '0']
- [digital_descrambler_bb_0, '0', blocks_uchar_to_float_0_0, '0']

metadata:
  file_format: 1
