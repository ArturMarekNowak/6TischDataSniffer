options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: xDDD
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandpassfilterhighcutoff
  id: variable_qtgui_range
  parameters:
    label: HighCutoff
    orient: Qt.Horizontal
    start: '1000'
    step: '1000'
    stop: samp_rate / 2
    value: samp_rate / 2
  states: {}
- name: bandpassfilterlowcutoff
  id: variable_qtgui_range
  parameters:
    label: LowCutoff
    orient: Qt.Horizontal
    start: '1000'
    step: '1000'
    stop: samp_rate / 2.0
    value: '1000'
  states: {}
- name: centre_freq
  id: variable
  parameters:
    value: 863.042e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-37'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: centre_freq
    fftsize: '1024'
    name: '"Filtered"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: centre_freq
    fftsize: '1024'
    name: '"NotFiltered"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: float
    update_time: '10'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"NotFiltered"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Filtered"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: centre_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [rtlsdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
