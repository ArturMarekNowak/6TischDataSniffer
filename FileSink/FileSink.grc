options:
  parameters:
    author: artur
    generate_options: qt_gui
    id: DataSniffer6TSCHDataSniffer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 863.042e6
  states: {}
- name: length
  id: variable
  parameters:
    value: '9'
  states: {}
- name: mask
  id: variable
  parameters:
    value: '0x110'
  states: {}
- name: points
  id: variable
  parameters:
    value: '7000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate // 200000
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\artur\OneDrive\Desktop\6tschId65535.raw
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: centre_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
